# Keil uVision project Test.uvproj, settings and files
target Test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\StdPeriph_Driver\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library\CMSIS
    ../Libraries/CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
    ../Libraries/StdPeriph_Driver/src/: stm32f10x_dma.c
  group Libiary\StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_fsmc.c
  group Doc
    ../Doc/: readme.txt
  group user
    ../user/: delay.c lcd.c main.c nvic.c stm32f10x_it.c usart.c i2c.c mpu6050.c hmc5338l.c
target sdfsaf (ARM-ADS)
  device: STM32F103ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\User\wm8978;.\User\I2S;.\User\SD_Driver;.\User\FATS;.\User\WAV
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
